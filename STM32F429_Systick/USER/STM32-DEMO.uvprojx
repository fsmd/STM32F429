# Keil uVision project STM32-DEMO.uvprojx, settings and files
target STM32F429_USART3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\FWlib\inc;.\inc;..\CMSIS\Include;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f429_439xx.s
  group USER
    ./src/: led.c main.c stm32f4xx_it.c Tim2.c chipid.c usart3.c SysTick.c
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group Readme
    ../: Readme.txt
software components: CMSIS:CORE 4.3.0
