# Keil uVision project STM32_TIM2.uvprojx, settings and files
target STM32F429_TIM2 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: STM32-Tim2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\FWlib\inc;.\inc;..\CMSIS\Include;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f429_439xx.s
  group USER
    ./src/: led.c main.c stm32f4xx_it.c Tim2.c
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group Readme
    ../: Readme.txt
software components: CMSIS:CORE 4.3.0
